FILESEXTRAPATHS:prepend:congax7-ast2500 := "${THISDIR}/${PN}:"

